8 6 0 0 0
1	-0.577350269 -0.577350269 -0.577350269
2	 0.577350269 -0.577350269 -0.577350269
3	-0.577350269  0.577350269 -0.577350269
4	 0.577350269  0.577350269 -0.577350269
5	-0.577350269 -0.577350269  0.577350269
6	 0.577350269 -0.577350269  0.577350269
7	-0.577350269  0.577350269  0.577350269
8	 0.577350269  0.577350269  0.577350269
1 1 quad 3 4 2 1
2 1 quad 5 6 8 7
3 1 quad 1 2 6 5 
4 1 quad 3 7 8 4
5 1 quad 5 7 3 1
6 1 quad 2 4 8 6
