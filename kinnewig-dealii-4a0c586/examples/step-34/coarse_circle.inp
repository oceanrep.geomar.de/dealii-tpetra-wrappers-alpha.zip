10 10 0 0 0
1	0 1.0 0
2	0.587785252292 0.809016994375 0
3	0.951056516295 0.309016994375 0
4	0.951056516295 -0.309016994375 0
5	0.587785252292 -0.809016994375 0
6	0 -1.0 0
7	-0.587785252292 -0.809016994375 0
8	-0.951056516295 -0.309016994375 0
9	-0.951056516295 0.309016994375 0
10	-0.587785252292 0.809016994375 0
1 1 line 1 2
2 1 line 2 3
3 1 line 3 4
4 1 line 4 5
5 1 line 5 6
6 1 line 6 7
7 1 line 7 8
8 1 line 8 9
9 1 line 9 10
10 1 line 10 1
