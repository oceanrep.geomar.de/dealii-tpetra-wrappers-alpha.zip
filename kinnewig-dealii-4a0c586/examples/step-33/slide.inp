1494 1 quad 1624 1498 1638 1623 
1495 1 quad 1498 1499 1674 1638 
1496 1 quad 1499 1500 1673 1674 
1497 1 quad 1501 1502 1640 1639 
1498 1 quad 1502 1503 1641 1640 
1499 1 quad 1505 1506 1642 1641 
1500 1 quad 1506 1507 1643 1642 
1501 1 quad 1507 1508 1644 1643 
1502 1 quad 1508 1509 1645 1644 
1503 1 quad 1509 1510 1646 1645 
1504 1 quad 1510 1511 1647 1646 
1505 1 quad 1511 1512 1648 1647 
1506 1 quad 1512 1513 1649 1648 
1507 1 quad 1513 1514 1650 1649 
1508 1 quad 1514 1515 1651 1650 
1509 1 quad 1520 1583 1652 1519 
1510 1 quad 1583 1584 1653 1652 
1511 1 quad 1584 1585 1654 1653 
1512 1 quad 1585 1586 1655 1654 
1513 1 quad 1586 1587 1656 1655 
1514 1 quad 1587 1588 1657 1656 
1515 1 quad 1588 1589 1658 1657 
1516 1 quad 1589 1660 1659 1658 
1517 1 quad 1589 1590 1661 1660 
1518 1 quad 1590 1591 1662 1661 
1519 1 quad 1591 1592 1663 1662 
1520 1 quad 1592 1593 1664 1663 
1521 1 quad 1593 1594 1665 1664 
1522 1 quad 1594 1595 1666 1665 
1523 1 quad 1595 1596 1625 1666 
1524 1 quad 1651 1612 1667 1650 
1525 1 quad 1612 1613 1696 1667 
1526 1 quad 1613 1614 1695 1696 
1527 1 quad 1614 1615 1694 1695 
1528 1 quad 1615 1616 1668 1694 
1529 1 quad 1616 1617 1669 1668 
1530 1 quad 1617 1618 1670 1669 
1531 1 quad 1618 1619 1671 1670 
1532 1 quad 1619 1620 1672 1671 
1533 1 quad 1620 1621 1673 1672 
1534 1 quad 1621 1622 1674 1673 
1535 1 quad 1674 1622 1623 1638 
1536 1 quad 1597 1598 1675 1637 
1537 1 quad 1598 1599 1676 1675 
1538 1 quad 1599 1600 1677 1676 
1539 1 quad 1600 1601 1678 1677 
1540 1 quad 1601 1602 1679 1678 
1541 1 quad 1602 1603 1680 1679 
1542 1 quad 1603 1604 1681 1680 
1543 1 quad 1604 1605 1682 1681 
1544 1 quad 1605 1606 1683 1682 
1545 1 quad 1606 1607 1684 1683 
1546 1 quad 1607 1608 1685 1684 
1547 1 quad 1608 1609 1686 1685 
1548 1 quad 1609 1610 1687 1686 
1549 1 quad 1610 1611 1688 1687 
1550 1 quad 1611 1515 1516 1688 
1551 1 quad 1625 1626 1689 1666 
1552 1 quad 1626 1627 1628 1689 
1553 1 quad 1628 1629 1719 1689 
1554 1 quad 1629 1630 1718 1719 
1555 1 quad 1630 1631 1717 1718 
1556 1 quad 1631 1632 1716 1717 
1557 1 quad 1632 1633 1715 1716 
1558 1 quad 1633 1634 1714 1715 
1559 1 quad 1634 1635 1713 1714 
1560 1 quad 1635 1636 1690 1713 
1561 1 quad 1636 1637 1675 1690 
1562 1 quad 1516 1517 1707 1688 
1563 1 quad 1517 1518 1706 1707 
1564 1 quad 1518 1519 1652 1706 
1565 1 quad 1641 1642 1711 1640 
1566 1 quad 1642 1643 1710 1711 
1567 1 quad 1643 1644 1691 1710 
1568 1 quad 1644 1645 1692 1691 
1569 1 quad 1645 1646 1693 1692 
1570 1 quad 1646 1647 1694 1693 
1571 1 quad 1647 1648 1695 1694 
1572 1 quad 1648 1649 1696 1695 
1573 1 quad 1696 1649 1650 1667 
1574 1 quad 1675 1676 1697 1690 
1575 1 quad 1676 1677 1698 1697 
1576 1 quad 1677 1678 1699 1698 
1577 1 quad 1678 1679 1700 1699 
1578 1 quad 1679 1680 1701 1700 
1579 1 quad 1680 1681 1702 1701 
1580 1 quad 1681 1682 1703 1702 
1581 1 quad 1682 1683 1704 1703 
1582 1 quad 1683 1684 1705 1704 
1583 1 quad 1684 1685 1706 1705 
1584 1 quad 1685 1686 1707 1706 
1585 1 quad 1688 1707 1686 1687 
1586 1 quad 1694 1668 1708 1693 
1587 1 quad 1668 1669 1709 1708 
1588 1 quad 1669 1670 1727 1709 
1589 1 quad 1670 1671 1729 1727 
1590 1 quad 1671 1672 1712 1729 
1591 1 quad 1652 1653 1705 1706 
1592 1 quad 1653 1654 1704 1705 
1593 1 quad 1654 1655 1703 1704 
1594 1 quad 1655 1656 1702 1703 
1595 1 quad 1656 1657 1701 1702 
1596 1 quad 1657 1658 1700 1701 
1597 1 quad 1658 1659 1699 1700 
1598 1 quad 1699 1659 1713 1698 
1599 1 quad 1659 1660 1714 1713 
1600 1 quad 1660 1661 1715 1714 
1601 1 quad 1661 1662 1716 1715 
1602 1 quad 1662 1663 1717 1716 
1603 1 quad 1663 1664 1718 1717 
1604 1 quad 1664 1665 1719 1718 
1605 1 quad 1719 1665 1666 1689 
1606 1 quad 1713 1690 1697 1698 
1607 1 quad 1691 1692 1721 1720 
1608 1 quad 1693 1708 1721 1692 
1609 1 quad 1708 1709 1720 1721 
1610 1 quad 420 419 344 345 
1611 1 quad 345 346 347 420 
1612 1 quad 872 926 1722 846 
1613 1 quad 926 845 1723 1722 
1614 1 quad 1722 1723 1725 1724 
1615 1 quad 846 1722 1724 847 
1616 1 quad 847 1724 717 718 
1617 1 quad 1724 1725 716 717 
1618 1 quad 1504 1505 1641 1503 
1619 1 quad 1504 1408 1409 1410 
1620 1 quad 1521 1520 1424 1425 
1621 1 quad 1425 1427 1428 1521 
1622 1 quad 1473 1400 1565 1472 
1623 1 quad 1691 1720 1726 1710 
1624 1 quad 1720 1709 1727 1726 
1625 1 quad 1726 1727 1729 1728 
1626 1 quad 1710 1726 1728 1711 
1627 1 quad 1711 1728 1639 1640 
1628 1 quad 1728 1729 1712 1639 
1629 1 quad 1274 1730 1426 1731 
1630 1 quad 1730 1275 1427 1426 
1631 1 quad 1426 1427 1425 1731 
1632 1 quad 1712 1672 1673 1500 
1633 1 quad 1712 1500 1501 1639 
1633 1 line 67 180 
1634 1 line 180 179 
1635 1 line 179 178 
1636 1 line 178 177 
1637 1 line 177 176 
1638 1 line 176 175 
1639 1 line 175 174 
1640 1 line 174 173 
1641 1 line 173 172 
1642 1 line 172 171 
1643 1 line 171 170 
1644 1 line 170 169 
1645 1 line 169 168 
1646 1 line 168 167 
1647 1 line 167 166 
1648 1 line 166 165 
1649 1 line 165 164 
1650 1 line 164 163 
1651 1 line 163 162 
1652 1 line 162 161 
1653 1 line 161 160 
1654 1 line 160 159 
1655 1 line 159 158 
1656 1 line 158 157 
1657 1 line 157 156 
1658 1 line 156 155 
1659 1 line 155 154 
1660 1 line 154 153 
1661 1 line 153 152 
1662 1 line 152 151 
1663 1 line 151 150 
1664 1 line 150 149 
1665 1 line 149 148 
1666 1 line 148 147 
1667 1 line 147 146 
1668 1 line 146 145 
1669 1 line 145 144 
1670 1 line 144 143 
1671 1 line 143 142 
1672 1 line 142 141 
1673 1 line 141 140 
1674 1 line 140 139 
1675 1 line 139 138 
1676 1 line 138 137 
1677 1 line 137 136 
1678 1 line 136 135 
1679 1 line 135 134 
1680 2 line 66 34 
1681 2 line 9 35 
1682 2 line 35 36 
1683 2 line 36 37 
1684 2 line 37 38 
1685 2 line 38 39 
1686 2 line 39 40 
1687 2 line 40 41 
1688 2 line 41 42 
1689 2 line 42 43 
1690 2 line 43 44 
1691 2 line 44 45 
1692 2 line 45 46 
1693 2 line 46 47 
1694 2 line 47 48 
1695 2 line 48 49 
1696 2 line 49 50 
1697 2 line 50 51 
1698 2 line 51 52 
1699 2 line 52 53 
1700 2 line 53 54 
1701 2 line 54 55 
1702 2 line 55 56 
1703 2 line 56 57 
1704 2 line 57 58 
1705 2 line 58 59 
1706 2 line 59 60 
1707 2 line 60 61 
1708 2 line 61 62 
1709 2 line 62 63 
1710 2 line 63 64 
1711 2 line 64 65 
1712 2 line 65 66 
1713 3 line 133 67 
1714 3 line 132 133 
1715 3 line 131 132 
1716 3 line 34 68 
1717 3 line 68 69 
1718 3 line 69 70 
1719 3 line 70 71 
1720 3 line 71 72 
1721 3 line 72 73 
1722 3 line 73 74 
1723 3 line 74 75 
1724 3 line 75 76 
1725 3 line 76 77 
1726 3 line 77 78 
1727 3 line 78 79 
1728 3 line 79 80 
1729 3 line 80 81 
1730 3 line 81 82 
1731 3 line 82 83 
1732 3 line 83 84 
1733 3 line 84 85 
1734 3 line 85 86 
1735 3 line 86 87 
1736 3 line 87 88 
1737 3 line 88 89 
1738 3 line 89 90 
1739 3 line 90 91 
1740 3 line 91 92 
1741 3 line 92 93 
1742 3 line 93 94 
1743 3 line 94 95 
1744 3 line 95 96 
1745 3 line 96 97 
1746 3 line 97 98 
1747 3 line 98 99 
1748 3 line 99 100 
1749 3 line 100 101 
1750 3 line 101 102 
1751 3 line 102 103 
1752 3 line 103 104 
1753 3 line 104 105 
1754 3 line 105 106 
1755 3 line 106 107 
1756 3 line 107 108 
1757 3 line 108 109 
1758 3 line 109 110 
1759 3 line 110 111 
1760 3 line 111 112 
1761 3 line 112 113 
1762 3 line 113 114 
1763 3 line 114 115 
1764 3 line 115 116 
1765 3 line 116 117 
1766 3 line 117 118 
1767 3 line 118 119 
1768 3 line 119 120 
1769 3 line 120 121 
1770 3 line 121 122 
1771 3 line 122 123 
1772 3 line 123 124 
1773 3 line 124 125 
1774 3 line 125 126 
1775 3 line 126 127 
1776 3 line 127 128 
1777 3 line 128 129 
1778 3 line 129 130 
1779 3 line 130 131 
1780 4 line 185 181 
1781 4 line 134 182 
1782 4 line 182 183 
1783 4 line 183 184 
1784 4 line 184 185 
1785 4 line 181 187 
1786 4 line 187 188 
1787 4 line 188 189 
1788 4 line 189 190 
1789 4 line 190 191 
1790 4 line 191 192 
1791 4 line 192 186 
1792 4 line 186 193 
1793 4 line 193 194 
1794 4 line 194 1 
1795 4 line 1 3 
1796 4 line 3 4 
1797 4 line 4 5 
1798 4 line 5 6 
1799 4 line 6 7 
1800 4 line 7 8 
1801 4 line 8 2 
1802 4 line 2 10 
1803 4 line 10 11 
1804 4 line 11 12 
1805 4 line 12 13 
1806 4 line 13 14 
1807 4 line 14 15 
1808 4 line 15 16 
1809 4 line 16 17 
1810 4 line 17 18 
1811 4 line 18 19 
1812 4 line 19 20 
1813 4 line 20 21 
1814 4 line 21 22 
1815 4 line 22 23 
1816 4 line 23 24 
1817 4 line 24 25 
1818 4 line 25 26 
1819 4 line 26 27 
1820 4 line 27 28 
1821 4 line 28 29 
1822 4 line 29 30 
1823 4 line 30 31 
1824 4 line 31 32 
1825 4 line 32 33 
1826 4 line 33 9 

