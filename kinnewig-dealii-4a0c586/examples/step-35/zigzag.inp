45 56 0 0 0
0  0  1   0.
1  3  1   0.
2  4.5  0   0.
3  6  1   0.
4  7.5  0   0.
5  9  1   0.
6  10.5  0   0.
7  12  1   0.
8  15  1   0.
9  0  1.6   0.
10  3  1.6   0.
11  4.5  1   0.
12  6  1.6   0.
13  7.5  1   0.
14  9  1.6   0.
15  10.5  1   0.
16  12  1.6   0.
17  15  1.6   0.
18  0  2.5   0.
19  3  2.5   0.
20  4.5  2.5   0.
21  6  2.5   0.
22  7.5  2.5   0.
23  9  2.5   0.
24  10.5  2.5   0.
25  12  2.5   0.
26  15  2.5   0.
27  0  3.4   0.
28  3  3.4   0.
29  4.5  4   0.
30  6  3.4   0.
31  7.5  4   0.
32  9  3.4   0.
33  10.5  4   0.
34  12  3.4   0.
35  15  3.4   0.
36  0  4   0.
37  3  4   0.
38  4.5  5   0.
39  6  4   0.
40  7.5  5   0.
41  9  4   0.
42  10.5  5   0.
43  12  4   0.
44  15  4   0.
1  1 quad 0 1 10 9
2  1 quad 1 2 11 10
3  1 quad 2 3 12 11
4  1 quad 3 4 13 12
5  1 quad 4 5 14 13
6  1 quad 5 6 15 14
7  1 quad 6 7 16 15
8  1 quad 7 8 17 16
9  1 quad 9 10 19 18
10  1 quad 10 11 20 19
11  1 quad 11 12 21 20
12  1 quad 12 13 22 21
13  1 quad 13 14 23 22
14  1 quad 14 15 24 23
15  1 quad 15 16 25 24
16  1 quad 16 17 26 25
17  1 quad 18 19 28 27
18  1 quad 19 20 29 28
19  1 quad 20 21 30 29
20  1 quad 21 22 31 30
21  1 quad 22 23 32 31
22  1 quad 23 24 33 32
23  1 quad 24 25 34 33
24  1 quad 25 26 35 34
25  1 quad 27 28 37 36
26  1 quad 28 29 38 37
27  1 quad 29 30 39 38
28  1 quad 30 31 40 39
29  1 quad 31 32 41 40
30  1 quad 32 33 42 41
31  1 quad 33 34 43 42
32  1 quad 34 35 44 43
33 0 line 0 1
34 0 line 1 2
35 0 line 2 3
36 0 line 3 4
37 0 line 4 5
38 0 line 5 6
39 0 line 6 7
40 0 line 7 8
41 0 line 44 43
42 0 line 43 42
43 0 line 42 41
44 0 line 41 40
45 0 line 40 39
46 0 line 39 38
47 0 line 38 37
48 0 line 37 36
49 1 line 0 9
50 1 line 9 18
51 1 line 18 27
52 1 line 27 36
53 2 line 8 17
54 2 line 17 26
55 2 line 26 35
56 2 line 35 44
