82 104 0 0 0
 0 01.75 02.25 0.00
 1 01.1 01.1 0.00
 2 02.0 01.0 0.00
 3 03.0 0.0 0.00
 4 02.0 0.0 0.00
 5 01.0 02.0 0.00
 6 00 03.075 0.00
 7 00 02.050 0.00
 8 01.0 00 0.00
 9 0.0 01.025 0.00
 10 0.0 0.0 0.00
 11 03.0 02.0 0.00
 12 01.1 02.9 0.00
 13 02.0 03.0 0.00
 14 02.9 02.9 0.00
 15 04.0 03.0 0.00
 16 06.0 02.0 0.00
 17 04.0 02.0 0.00
 18 06.0 01.0 0.00
 19 08.0 01.0 0.00
 20 10.00 0.0 0.00
 21 08.0 0.0 0.00
 22 02.9 01.1 0.00
 23 04.0 01.0 0.00
 24 06.0 0.0 0.00
 25 04.0 0.0 0.00
 26 10.00 02.0 0.00
 27 06.0 03.0 0.00
 28 08.0 03.0 0.00
 29 08.0 02.0 0.00
 30 10.00 03.0 0.00
 31 12.0 03.0 0.00
 32 14.0 02.0 0.00
 33 12.0 02.0 0.00
 34 14.0 01.0 0.00
 35 10.0 01.0 0.00
 36 12.0 01.0 0.00
 37 14.0 0.0 0.00
 38 12.0 0.0 0.00
 39 14.0 03.0 0.00
 40 03.0 04.1 0.00
 41 02.0 04.1 0.00
 42 01.0 04.1 0.00
 43 00. 04.1 0.00
 44 10.0 04.1 0.00
 45 08.0 04.1 0.00
 46 06.0 04.1 0.00
 47 04.0 04.1 0.00
 48 14.0 04.1 0.00
 49 12.0 04.1 0.00
 50 01.5 02.0 0.00
 51 01.75 01.75 0.00
 52 02.0 01.5 0.00
 53 02.25 01.75 0.00
 54 02.5 02.0 0.00
 55 02.25 02.25 0.00
 56 02.0 02.5 0.00
57 16.2 0 0.0
58 16.2 01. 0.0
59 16.2 02. 0.0
60 16.2 03. 0.0
61 16.2 04.1 0.0
62 18.4 0 0.0
63 18.4 01. 0.0
64 18.4 02. 0.0
65 18.4 03. 0.0
66 18.4 04.1 0.0
67 20.6 0 0.0
68 20.6 01. 0.0
69 20.6 02. 0.0
70 20.6 03. 0.0
71 20.6 04.1 0.0
72 22.8 0 0.0
73 22.8 01. 0.0
74 22.8 02. 0.0
75 22.8 03. 0.0
76 22.8 04.1 0.0
77 25. 0 0.0
78 25. 01. 0.0
79 25. 02. 0.0
80 25. 03. 0.0
81 25. 04.1 0.0
 1 1 quad 10 8 1 9
 2 1 quad 8 4 2 1
 3 1 quad 9 1 5 7
 4 1 quad 4 3 22 2
 5 1 quad 3 25 23 22
 6 1 quad 22 23 17 11
 7 1 quad 11 17 15 14
 8 1 quad 14 15 47 40
 9 1 quad 13 14 40 41
 10 1 quad 7 5 12 6
 11 1 quad 12 13 41 42
 12 1 quad 6 12 42 43
 13 1 quad 25 24 18 23
 14 1 quad 24 21 19 18
 15 1 quad 18 19 29 16
 16 1 quad 23 18 16 17
 17 1 quad 21 20 35 19
 18 1 quad 20 38 36 35
 19 1 quad 35 36 33 26
 20 1 quad 19 35 26 29
 21 1 quad 29 26 30 28
 22 1 quad 26 33 31 30
 23 1 quad 30 31 49 44
 24 1 quad 28 30 44 45
 25 1 quad 17 16 27 15
 26 1 quad 16 29 28 27
 27 1 quad 27 28 45 46
 28 1 quad 15 27 46 47
 29 1 quad 38 37 34 36
 30 1 quad 36 34 32 33
 31 1 quad 33 32 39 31
 32 1 quad 31 39 48 49
 33 1 quad 1 51 50 5
 34 1 quad 2 52 51 1
 35 1 quad 22 53 52 2
 36 1 quad 11 54 53 22
 37 1 quad 14 55 54 11
 38 1 quad 13 56 55 14
 39 1 quad 12 0 56 13
 40 1 quad 5 50 0 12
41 1 quad 57 58 34 37
42 1 quad 58 59 32 34
43 1 quad 59 60 39 32
44 1 quad 60 61 48 39
45 1 quad 62 63 58 57
46 1 quad 63 64 59 58
47 1 quad 64 65 60 59
48 1 quad 65 66 61 60
49 1 quad 67 68 63 62
50 1 quad 68 69 64 63
51 1 quad 69 70 65 64
52 1 quad 70 71 66 65
53 1 quad 72 73 68 67
54 1 quad 73 74 69 68
55 1 quad 74 75 70 69
56 1 quad 75 76 71 70
57 1 quad 77 78 73 72
58 1 quad 78 79 74 73
59 1 quad 79 80 75 74
60 1 quad 80 81 76 75
 41  1 line 10 8
 42  2 line 10 9
 43  1 line 8 4
 44  2 line 9 7
 45  1 line 4 3
 46  1 line 3 25
 47  1 line 40 47
 48  1 line 41 40
 49  2 line 7 6
 50  1 line 42 41
 51  1 line 43 42
 52  2 line 6 43
 53  1 line 25 24
 54  1 line 24 21
 55  1 line 21 20
 56  1 line 20 38
 57  1 line 44 49
 58  1 line 45 44
 59  1 line 46 45
 60  1 line 47 46
 61  1 line 38 37
 62  3 line 77 78
 63  3 line 78 79
 64  3 line 79 80
 65  3 line 80 81
 66  1 line 49 48
 67  4 line 51 50
 68  4 line 52 51
 69  4 line 53 52
 70  4 line 54 53
 71  4 line 55 54
 72  4 line 56 55
 73  4 line 0  56
 74  4 line 50 0
75 1 line 37 57
76 1 line 48 61
77 1 line 57 62
78 1 line 61 66
79 1 line 62 67
80 1 line 66 71
81 1 line 67 72
82 1 line 71 76
83 1 line 72 77
84 1 line 76 81
