25 20 0 0 0
1  -0.7071 -0.7071 0
2  0.7071 -0.7071 0
3  -0.2668 -0.2668 0
4  0.2668 -0.2668 0
5  -0.2668 0.2668 0
6  0.2668 0.2668 0
7  -0.7071 0.7071 0
8  0.7071 0.7071 0
9  0 -1 0
10  0.5 -0.5 0
11  0 -0.3139 0
12  -0.5 -0.5 0
13  0 -0.6621 0
14  -0.3139 0 0
15  -0.5 0.5 0
16  -1 0 0
17  -0.6621 0 0
18  0.3139 0 0
19  0 0.3139 0
20  0 0 0
21  1 0 0
22  0.5 0.5 0
23  0.6621 0 0
24  0 1 0
25  0 0.6621 0
1 0 quad    1 9 13 12 
2 0 quad    9 2 10 13 
3 0 quad    13 10 4 11 
4 0 quad    12 13 11 3 
5 0 quad    1 12 17 16 
6 0 quad    12 3 14 17 
7 0 quad    17 14 5 15 
8 0 quad    16 17 15 7 
9 0 quad    3 11 20 14 
10 0 quad    11 4 18 20 
11 0 quad    20 18 6 19 
12 0 quad    14 20 19 5 
13 0 quad    2 21 23 10 
14 0 quad    21 8 22 23 
15 0 quad    23 22 6 18 
16 0 quad    10 23 18 4 
17 0 quad    7 15 25 24 
18 0 quad    15 5 19 25 
19 0 quad    25 19 6 22 
20 0 quad    24 25 22 8 
